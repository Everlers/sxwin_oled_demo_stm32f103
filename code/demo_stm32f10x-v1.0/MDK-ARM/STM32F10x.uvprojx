# Keil uVision project STM32F10x.uvprojx, settings and files
target STM32F10x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST;..\APP;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HAL;..\MIIO;..\DRIVE;..\DRIVE\lcd;..\DRIVE\oled_ssd1322;..\DRIVE\oled;..\DRIVE\IS31FL3737;..\DRIVE\oneWire;..\DRIVE\delay;..\DRIVE\voice;..\DRIVE\rotarySwitch;..\APP\SpecialEfficiency;..\APP\image;..\DRIVE\led
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: main.c fun.c malloc.c
  group UI
    ../APP/: ui.c
    ../APP/image/: image.c
  group SpecialEfficiency
    ../APP/SpecialEfficiency/: seMove.c
  group OLED
    ../DRIVE/oled_ssd1322/: oled.c
  group DRIVE
    ../DRIVE/IS31FL3737/: airConditioner.c IS31FL3737.c
    ../DRIVE/voice/: voice.c
    ../DRIVE/TM1628/: TM1628.c
    ../DRIVE/oneWire/: oneWire.c
    ../DRIVE/rotarySwitch/: rotarySwitch.c
    ../DRIVE/delay/: delay.c
    ../DRIVE/led/: led.c
  group HAL
    ../HAL/: hal_buzzer.c hal_exti.c hal_key.c hal_spi.c hal_sys.c hal_usart.c hal_time.c
  group CMSIS
    ../Libraries/CMSIS/: stm32f10x_it.c system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../../../: README.md
